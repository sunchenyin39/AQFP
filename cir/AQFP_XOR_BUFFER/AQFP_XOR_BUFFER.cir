* AQFP_XOR_BUFFER test circuit

Iin_a	    0	    1	    pwl(0 0 5p -20u 500p -20u 510p -20u 1000p -20u 1010p +20u 1500p +20u 1510p +20u)
Iin_b	    0	    2	    pwl(0 0 5p -20u 500p -20u 510p +20u 1000p +20u 1010p -20u 1500p -20u 1510p +20u)
Iclk1	    0	    c1	    pwl(0 0 100p 0 120p 1.5m 400p 1.5m 420p 0 600p 0 620p 1.5m 900p 1.5m 920p 0 1100p 0 1120p 1.5m 1400p 1.5m 1420p 0 1600p 0 1620p 1.5m 1900p 1.5m 1920p 0)
Iclk2	    0	    c2	    pwl(0 0 110p 0 130p 1.5m 410p 1.5m 430p 0 610p 0 630p 1.5m 910p 1.5m 930p 0 1110p 0 1130p 1.5m 1410p 1.5m 1430p 0 1610p 0 1630p 1.5m 1910p 1.5m 1930p 0)
Iclk3	    0	    c3	    pwl(0 0 120p 0 140p 1.5m 420p 1.5m 440p 0 620p 0 640p 1.5m 920p 1.5m 940p 0 1120p 0 1140p 1.5m 1420p 1.5m 1440p 0 1620p 0 1640p 1.5m 1920p 1.5m 1940p 0)
Iclk4	    0	    c4	    pwl(0 0 130p 0 150p 1.5m 430p 1.5m 450p 0 630p 0 650p 1.5m 930p 1.5m 950p 0 1130p 0 1150p 1.5m 1430p 1.5m 1450p 0 1630p 0 1650p 1.5m 1930p 1.5m 1950p 0)
Iclk5	    0	    c5	    pwl(0 0 140p 0 160p 1.5m 440p 1.5m 460p 0 640p 0 660p 1.5m 940p 1.5m 960p 0 1140p 0 1160p 1.5m 1440p 1.5m 1460p 0 1640p 0 1660p 1.5m 1940p 1.5m 1960p 0)
X11         1       3       c1      c11     AQFP_BUFFER
X12         2       4       c11     c12     AQFP_NOT
X13         1       5       c12     c13     AQFP_NOT
X14         2       6       c13     0       AQFP_BUFFER
X21         3       4       7       c2      c21     AQFP_AND
X22         5       6       8       c21     0       AQFP_AND
X31         7       9       c3      c31     AQFP_BUFFER
X32         8       10      c31     0       AQFP_BUFFER
X41         9       10      11      c4      0       AQFP_OR
X51         11      12      c5      0       AQFP_BUFFER
Lout        12      0       6.8p

.subckt AQFP_AND a b q xin xout
Iin_const_0	    0	    1	    pwl(0 0 5p -20u)
X1              a       2       xin     4       AQFP_BUFFER
X2              b       3       4       xout    AQFP_BUFFER
X3              1       2       3       q       BRANCH_3_1
.ends AQFP_AND

.subckt AQFP_OR a b q xin xout
Iin_const_0	    0	    1	    pwl(0 0 5p +20u)
X1              a       2       xin     4       AQFP_BUFFER
X2              b       3       4       xout    AQFP_BUFFER
X3              1       2       3       q       BRANCH_3_1
.ends AQFP_OR

.subckt AQFP_BUFFER a q xin xout
.model jjmod jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)
.param B1=0.5
.param B2=0.5
.param Lin=1.22p
.param Lx=5.19p
.param L1=1.42p
.param L2=1.42p
.param Lq=8.27p
.param Lout=28.4p
.param K1=-0.22
.param K2=-0.22
.param K3=+0.472
Lin     a       1       Lin
Lx      xin     xout    Lx
B1	    0	    2	    jjmod   area=B1
L1	    2	    1	    L1
L2	    1	    3	    L2
B2	    3	    0	    jjmod	area=B2
Lq	    1	    0	    Lq
Lout	q	    0	    Lout
K1	    Lx	    L1	    K1
K2	    Lx	    L2	    K2
K3	    Lq	    Lout	K3
.ends AQFP_BUFFER

.subckt AQFP_NOT a q xin xout
.model jjmod jj(rtype=1, vg=2.8mV, cap=0.07pF, r0=160, rn=16, icrit=0.1mA)
.param B1=0.5
.param B2=0.5
.param Lin=1.22p
.param Lx=5.19p
.param L1=1.42p
.param L2=1.42p
.param Lq=8.27p
.param Lout=28.4p
.param K1=-0.22
.param K2=-0.22
.param K3=-0.472
Lin     a       1       Lin
Lx      xin     xout    Lx
B1	    0	    2	    jjmod   area=B1
L1	    2	    1	    L1
L2	    1	    3	    L2
B2	    3	    0	    jjmod	area=B2
Lq	    1	    0	    Lq
Lout	q	    0	    Lout
K1	    Lx	    L1	    K1
K2	    Lx	    L2	    K2
K3	    Lq	    Lout	K3
.ends AQFP_NOT

.subckt BRANCH_3_1 a b c q
.param L1=6.8p
.param L2=6.8p
.param L3=6.8p
.param Lout=2p
L1      a       1       L1
L2      b       1       L2
L3      c       1       L3
Lout    1       q       Lout
.ends BRANCH_3_1

.tran 0.25p 2000p 0 0.25p
.print i(Iin_a)
.print i(Iin_b)
.print i(Iclk1)
.print i(Iclk2)
.print i(Iclk3)
.print i(Iclk4)
.print i(Lout)
